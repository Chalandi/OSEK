# Keil uVision project PRJ_02.uvprojx, settings and files
target ARM_OS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PRJ_02 +hex
  c flags: Optim=3 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --bss_threshold=0
  c include: .\Application\MCAL;.\Application\OS;.\Application;.\Application\OS\HwPlatform\STM32
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\PRJ_MEM_MAP.sct
  link misc: --entry SysStartup_Init
--no_startup
--no_remove
  group Application
    ./Application/: Appli.c
  group MCAL
    ./Application/MCAL/: GPIO.h SysTickTimer.c SysTickTimer.h
  group Startup
    ./Application/: IntVect.c SysStartup.c
  group OS
    ./Application/OS/: OsAsm.c TCB.c TCB.h OS.c OsEvt.c OsTask.c OsAPIs.h OsAlarm.c OsTypes.h OsInternal.h OsCfg.h OsGenMac.h
  group Types
    ./Application/: types.h
